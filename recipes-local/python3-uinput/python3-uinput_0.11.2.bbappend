FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"
SRC_URI  += "file://fix_SO_to_EXT_SUFFIX.patch"