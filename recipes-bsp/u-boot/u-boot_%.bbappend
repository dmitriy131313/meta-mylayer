#FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI:append:sunxi = " file://boot.cmd"

# file://0001-my_commit.patch